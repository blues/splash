# IAR project splash.ewp, settings and files
configuration splash (ARM, debug)
  General.OGChipSelectEditMenu: STM32L433CC ST STM32L433CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; USING_IAR; STM32L433xx; STM32_THREAD_SAFE_STRATEGY=4; CJSON_NO_CLIB=0
  ICCARM.CCIncludePath2: ../System/Core/Inc; ../System/Drivers/STM32L4xx_HAL_Driver/Inc; ../System/Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../System/Middlewares/Third_Party/FreeRTOS/Source/include; ../System/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../System/Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../System/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../System/Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../System/Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../System/Drivers/CMSIS/Include; ../System/Utilities/lpm/tiny_lpm; ../System/Utilities/misc; ../System/Utilities/timer; ../System/Utilities/trace/adv_trace; ../System/Global; ../App; ../App/json; ../App/json/note-c; $PROJ_DIR$; ../System/Core/Weak
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../System/Core/Inc
  OBJCOPY.OOCOutputFile: splash.bin
  ILINK.IlinkOutputFile: splash.out
  ILINK.IlinkIcfFile: stm32l433xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    ../App/: app.c audio.c buffer.c button.c diag.c led.c maintask.c post.c post.h req.c reqtask.c serial.c simple.c
  group App/ST
    ../App/st/: arm_fir_decimate_init_q15.c arm_fir_decimate_q15.c iir_hp.c lut_filter.c pdm2pcm.c
  group Core
    ../System/Core/Src/: adc.c can.c debug_if.c dma.c flash_if.c gpio.c heap_4.c i2c.c lptim.c main.c rng.c rtc.c sai.c spi.c stm32_lpm_if.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c stm32l4xx_it.c timer_if.c usart.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c wwdg.c
    ../System/Core/Weak/: app_weak.c
  group Drivers/CMSIS
    ../System/Core/Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../System/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_lptim.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_spi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_usb.c
  group EWARM
    ./: dlib_lock_glue.c startup_stm32l433xx.s
  group Global
    ../System/Global/: amd5.c array.c base64.c crc16.c crc32.c debug.c float16.c gerr.c gmem.c loc.c md5hash.c memmem.c mutex.c os.c rand.c rrandom.c strl.c task.c timegm.c timer.c tss.c
  group Middlewares/FreeRTOS
    ../System/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../System/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../System/Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/USB
    ../System/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../System/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Utilities
    ../System/Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../System/Utilities/misc/: stm32_mem.c
    ../System/Utilities/timer/: stm32_timer.c
